# Keil uVision project ZWJ_GeneralFramework.uvprojx, settings and files
target ZWJ_GeneralFramework (6140001::V6.14.1::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ZWJ_GeneralFramework +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=4
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,CC_ARM
  c misc: -frtti
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../FrameComponets/Bsps/gpio;../FrameComponets/Bsps/config;../FrameComponets/Apps/MainFrame;../FrameComponets/Algorithm/filter;../FrameComponets/Algorithm/linear_math;../FrameComponets/Algorithm/pid;../FrameComponets/Algorithm/std_math;../FrameComponets/Bsps/dwt;../FrameComponets/Bsps/uart;../FrameComponets/Sys/System;../FrameComponets/Sys/StateCore;../FrameComponets/Mods/key;../FrameComponets/Mods/led
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsps
    ../FrameComponets/Bsps/dwt/: bsp_dwt.c
    ../FrameComponets/Bsps/gpio/: bsp_gpio.c
    ../FrameComponets/Bsps/uart/: bsp_uart.c
  group Mods
    ../FrameComponets/Mods/led/: led.cpp
    ../FrameComponets/Mods/key/: key.cpp
  group Sys
    ../FrameComponets/Sys/System/: System.cpp RtosCpp.cpp
    ../FrameComponets/Sys/StateCore/: StateCore.cpp
  group Apps
    ../FrameComponets/Apps/MainFrame/: MainFrame.cpp
  group Algorithm
    ../FrameComponets/Algorithm/pid/: pid.cpp
    ../FrameComponets/Algorithm/filter/: filter.cpp
    ../FrameComponets/Algorithm/std_math/: std_math.cpp
    ../FrameComponets/Algorithm/linear_math/: linear_math.cpp
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
